# Keil uVision project Base.uvprojx, settings and files
target Base Configuration (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Base Configuration +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,UESTC__ONE_POINT_FIVE_S__NO_1
  c misc: --C99
  c include: ..\Inc;   ..\Drivers\STM32F4xx_HAL_Driver\Inc;   ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;   ..\Drivers\CMSIS\Include;   ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;   .\App;   .\Bsp;   ..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;   ..\Middlewares\Third_Party\FreeRTOS\Source\include;   ..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;   .\Lib;   .\Drv
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c main.c gpio.c can.c stm32f4xx_hal_msp.c usart.c tim.c dma.c freertos.c rng.c spi.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f405xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c event_groups.c list.c croutine.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_can.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c
  group Bsp
    ./Bsp/: bsp_can.c bsp_can.h bsp_uart.c bsp_uart.h bsp_pid.c bsp_pid.h bsp_oled.c bsp_oled.h
  group App
    ./App/: task_init.c task_init.h task_underpan.c task_underpan.h task_debug.c task_debug.h task_check.c task_check.h timer_canSender.c timer_canSender.h task_bulletLoading.c task_bulletLoading.h task_keyPress.c task_keyPress.h task_oled.c task_oled.h task_detect.c task_detect.h
  group Drv
    ./Drv/: drv_gui.c drv_gui.h
  group Lib
    ./Lib/: includes.h junru_libs.c junru_libs.h judgement_libs.c judgement_libs.h filter_libs.c filter_libs.h data_libs.c libmpllib.lib
  group Doc
    ./Doc/: cofiguration.txt history.txt writing_format.txt
